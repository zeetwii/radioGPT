options:
  parameters:
    author: ZeeTwii
    copyright: '2023'
    description: A GNURadio module meant to convert wav files into RF audio
    generate_options: qt_gui
    id: radioGPT
    output_language: python
    title: Radio GPT
  states: {}

blocks:
- name: audioRate
  id: variable
  parameters:
    value: 352e3
  states: {}
- name: centerFreq
  id: variable
  parameters:
    value: 88e6
  states: {}
- name: mul
  id: variable
  parameters:
    value: '1'
  states: {}
- name: quadRate
  id: variable
  parameters:
    value: audioRate*2
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(audioRate)
    fh: '-1.0'
    max_dev: 500e3
    quad_rate: int(quadRate)
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mul
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/sf_GitHub/radioGPT/PCMgettysburg.wav
    repeat: 'True'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: centerFreq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quadRate)
    interp: int(sampleRate)
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: int(centerFreq)
    samp_rate: int(sampleRate)
    type: fc32
    vga: '24'
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
