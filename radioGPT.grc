options:
  parameters:
    author: ZeeTwii
    copyright: '2023'
    description: A GNURadio module meant to convert wav files into RF audio
    generate_options: qt_gui
    id: radioGPT
    output_language: python
    title: Radio GPT
  states: {}

blocks:
- name: audioRate
  id: variable
  parameters:
    value: 768e3
  states: {}
- name: centerFreq
  id: variable
  parameters:
    value: 88e6
  states: {}
- name: quadRate
  id: variable
  parameters:
    value: audioRate*1
  states: {}
- name: sampleRate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(audioRate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(quadRate)
    tau: '75e-6'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /media/sf_GitHub/radioGPT/people-talking-in-small-room-6064.wav
    repeat: 'True'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: sampleRate/quadRate
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: sampleRate
    fc: centerFreq
    fftsize: '1024'
    showrf: 'True'
    type: complex
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: int(centerFreq)
    samp_rate: int(sampleRate)
    type: fc32
    vga: '47'
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_sink_x_0, '0']
- [analog_wfm_tx_0, '0', soapy_hackrf_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [mmse_resampler_xx_0, '0', analog_wfm_tx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
