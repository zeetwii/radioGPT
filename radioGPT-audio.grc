options:
  parameters:
    author: ZeeTwii
    copyright: '2023'
    description: A radio chatbot
    generate_options: qt_gui
    id: radioGPT_audio
    output_language: python
    title: RadioGPT
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: freq
  id: variable
  parameters:
    value: 88e6
  states: {}
- name: mul
  id: variable
  parameters:
    value: '1'
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate * 16
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: int(audio_rate)
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: int(quad_rate)
    tau: '75e-6'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mul
    type: float
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(quad_rate)
    interp: int(samp_rate)
    type: ccc
  states: {}
- name: soapy_hackrf_sink_0
  id: soapy_hackrf_sink
  parameters:
    amp: 'True'
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
    vga: '47'
  states: {}

connections:
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', soapy_hackrf_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
